v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 160 -4680 180 -4680 {
lab=VPWR}
N 160 -4660 180 -4660 {
lab=VGND}
N 190 -4540 1170 -4540 {
lab=a[4]}
N 240 -4540 240 -4500 {
lab=a[4]}
N 320 -4500 1170 -4500 {
lab=#net1}
N 190 -4460 1170 -4460 {
lab=a[3]}
N 240 -4460 240 -4420 {
lab=a[3]}
N 320 -4420 1170 -4420 {
lab=#net2}
N 190 -4380 1170 -4380 {
lab=a[2]}
N 240 -4380 240 -4340 {
lab=a[2]}
N 320 -4340 1170 -4340 {
lab=#net3}
N 190 -4300 1170 -4300 {
lab=a[1]}
N 240 -4300 240 -4260 {
lab=a[1]}
N 320 -4260 1170 -4260 {
lab=#net4}
N 190 -4220 1170 -4220 {
lab=a[0]}
N 240 -4220 240 -4180 {
lab=a[0]}
N 320 -4180 1170 -4180 {
lab=#net5}
N 1170 -4180 1170 -4130 {
lab=#net5}
N 1150 -4260 1150 -4130 {
lab=#net4}
N 1090 -4220 1090 -4130 {
lab=a[0]}
N 1070 -4260 1070 -4130 {
lab=#net4}
N 1010 -4180 1010 -4130 {
lab=#net5}
N 990 -4300 990 -4130 {
lab=a[1]}
N 930 -4220 930 -4120 {
lab=a[0]}
N 910 -4300 910 -4130 {
lab=a[1]}
N 830 -4340 830 -4130 {
lab=#net3}
N 750 -4380 750 -4130 {
lab=a[2]}
N 670 -4340 670 -4130 {
lab=#net3}
N 590 -4380 590 -4130 {
lab=a[2]}
N 810 -4420 810 -4130 {
lab=#net2}
N 730 -4420 730 -4130 {
lab=#net2}
N 650 -4460 650 -4130 {
lab=a[3]}
N 570 -4460 570 -4130 {
lab=a[3]}
N 160 -4550 180 -4550 {
lab=a[4:0]
bus=true}
N 180 -4550 180 -4230 {
lab=a[4:0]
bus=true}
N 1160 -4000 1220 -4000 {
lab=#net6}
N 820 -3960 1220 -3960 {
lab=#net7}
N 1080 -3880 1220 -3880 {
lab=#net8}
N 820 -3840 1220 -3840 {
lab=#net7}
N 1000 -3760 1220 -3760 {
lab=#net9}
N 820 -3720 1220 -3720 {
lab=#net7}
N 820 -3600 1220 -3600 {
lab=#net7}
N 920 -3640 1220 -3640 {
lab=#net10}
N 1160 -3520 1220 -3520 {
lab=#net6}
N 1080 -3400 1220 -3400 {
lab=#net8}
N 1000 -3280 1220 -3280 {
lab=#net9}
N 920 -3160 1220 -3160 {
lab=#net10}
N 740 -3480 1220 -3480 {
lab=#net11}
N 740 -3360 1220 -3360 {
lab=#net11}
N 740 -3240 1220 -3240 {
lab=#net11}
N 740 -3120 1220 -3120 {
lab=#net11}
N 1160 -3040 1220 -3040 {
lab=#net6}
N 1080 -2920 1220 -2920 {
lab=#net8}
N 1000 -2800 1220 -2800 {
lab=#net9}
N 920 -2680 1220 -2680 {
lab=#net10}
N 1160 -2560 1220 -2560 {
lab=#net6}
N 1080 -2440 1220 -2440 {
lab=#net8}
N 1000 -2320 1220 -2320 {
lab=#net9}
N 920 -2200 1220 -2200 {
lab=#net10}
N 660 -3000 1220 -3000 {
lab=#net12}
N 660 -2880 1220 -2880 {
lab=#net12}
N 660 -2760 1220 -2760 {
lab=#net12}
N 660 -2640 1220 -2640 {
lab=#net12}
N 580 -2520 1220 -2520 {
lab=#net13}
N 580 -2400 1220 -2400 {
lab=#net13}
N 580 -2280 1220 -2280 {
lab=#net13}
N 580 -2160 1220 -2160 {
lab=#net13}
N 1160 -2080 1220 -2080 {
lab=#net6}
N 820 -2040 1220 -2040 {
lab=#net7}
N 400 -2000 1220 -2000 {
lab=#net1}
N 1080 -1960 1220 -1960 {
lab=#net8}
N 820 -1920 1220 -1920 {
lab=#net7}
N 400 -1880 1220 -1880 {
lab=#net1}
N 1000 -1840 1220 -1840 {
lab=#net9}
N 820 -1800 1220 -1800 {
lab=#net7}
N 400 -1760 1220 -1760 {
lab=#net1}
N 820 -1680 1220 -1680 {
lab=#net7}
N 400 -1640 1220 -1640 {
lab=#net1}
N 920 -1720 1220 -1720 {
lab=#net10}
N 1160 -1600 1220 -1600 {
lab=#net6}
N 400 -1520 1220 -1520 {
lab=#net1}
N 1080 -1480 1220 -1480 {
lab=#net8}
N 400 -1400 1220 -1400 {
lab=#net1}
N 1000 -1360 1220 -1360 {
lab=#net9}
N 400 -1280 1220 -1280 {
lab=#net1}
N 400 -1160 1220 -1160 {
lab=#net1}
N 920 -1240 1220 -1240 {
lab=#net10}
N 740 -1560 1220 -1560 {
lab=#net11}
N 740 -1440 1220 -1440 {
lab=#net11}
N 740 -1320 1220 -1320 {
lab=#net11}
N 740 -1200 1220 -1200 {
lab=#net11}
N 1160 -1120 1220 -1120 {
lab=#net6}
N 400 -1040 1220 -1040 {
lab=#net1}
N 1080 -1000 1220 -1000 {
lab=#net8}
N 400 -920 1220 -920 {
lab=#net1}
N 1000 -880 1220 -880 {
lab=#net9}
N 400 -800 1220 -800 {
lab=#net1}
N 400 -680 1220 -680 {
lab=#net1}
N 920 -760 1220 -760 {
lab=#net10}
N 1160 -640 1220 -640 {
lab=#net6}
N 400 -560 1220 -560 {
lab=#net1}
N 1080 -520 1220 -520 {
lab=#net8}
N 400 -440 1220 -440 {
lab=#net1}
N 1000 -400 1220 -400 {
lab=#net9}
N 400 -320 1220 -320 {
lab=#net1}
N 400 -200 1220 -200 {
lab=#net1}
N 920 -280 1220 -280 {
lab=#net10}
N 660 -1080 1220 -1080 {
lab=#net12}
N 660 -960 1220 -960 {
lab=#net12}
N 660 -840 1220 -840 {
lab=#net12}
N 660 -720 1220 -720 {
lab=#net12}
N 580 -600 1220 -600 {
lab=#net13}
N 580 -480 1220 -480 {
lab=#net13}
N 580 -360 1220 -360 {
lab=#net13}
N 580 -240 1220 -240 {
lab=#net13}
N 480 -3920 1220 -3920 {
lab=a[4]}
N 480 -3800 1220 -3800 {
lab=a[4]}
N 480 -3680 1220 -3680 {
lab=a[4]}
N 480 -3560 1220 -3560 {
lab=a[4]}
N 480 -3440 1220 -3440 {
lab=a[4]}
N 480 -3320 1220 -3320 {
lab=a[4]}
N 480 -3200 1220 -3200 {
lab=a[4]}
N 480 -3080 1220 -3080 {
lab=a[4]}
N 480 -2960 1220 -2960 {
lab=a[4]}
N 480 -2840 1220 -2840 {
lab=a[4]}
N 480 -2720 1220 -2720 {
lab=a[4]}
N 480 -2600 1220 -2600 {
lab=a[4]}
N 480 -2480 1220 -2480 {
lab=a[4]}
N 480 -2360 1220 -2360 {
lab=a[4]}
N 480 -2240 1220 -2240 {
lab=a[4]}
N 480 -2120 1220 -2120 {
lab=a[4]}
N 480 -4540 480 -2120 {
lab=a[4]}
N 400 -4500 400 -200 {
lab=#net1}
N 580 -4020 580 -240 {
lab=#net13}
N 660 -4020 660 -720 {
lab=#net12}
N 740 -4020 740 -1200 {
lab=#net11}
N 820 -4020 820 -1680 {
lab=#net7}
N 920 -4020 920 -280 {
lab=#net10}
N 1000 -4020 1000 -400 {
lab=#net9}
N 1080 -4020 1080 -520 {
lab=#net8}
N 1160 -4020 1160 -640 {
lab=#net6}
N 1340 -3960 1470 -3960 {
lab=w[0]}
N 1480 -4020 1500 -4020 {
lab=w[31:0]}
N 1480 -4020 1480 -250 {
lab=w[31:0]
bus=true}
N 1340 -3840 1470 -3840 {
lab=w[1]}
N 1340 -3720 1470 -3720 {
lab=w[2]}
N 1340 -3600 1470 -3600 {
lab=w[3]}
N 1340 -3480 1470 -3480 {
lab=w[4]}
N 1340 -3360 1470 -3360 {
lab=w[5]}
N 1340 -3240 1470 -3240 {
lab=w[6]}
N 1340 -3120 1470 -3120 {
lab=w[7]}
N 1340 -3000 1470 -3000 {
lab=w[8]}
N 1340 -2880 1470 -2880 {
lab=w[9]}
N 1340 -2760 1470 -2760 {
lab=w[10]}
N 1340 -2640 1470 -2640 {
lab=w[11]}
N 1340 -2520 1470 -2520 {
lab=w[12]}
N 1340 -2400 1470 -2400 {
lab=w[13]}
N 1340 -2280 1470 -2280 {
lab=w[14]}
N 1340 -2160 1470 -2160 {
lab=w[15]}
N 1340 -2040 1470 -2040 {
lab=w[16]}
N 1340 -1920 1470 -1920 {
lab=w[17]}
N 1340 -1800 1470 -1800 {
lab=w[18]}
N 1340 -1680 1470 -1680 {
lab=w[19]}
N 1340 -1560 1470 -1560 {
lab=w[20]}
N 1340 -1440 1470 -1440 {
lab=w[21]}
N 1340 -1320 1470 -1320 {
lab=w[22]}
N 1340 -1200 1470 -1200 {
lab=w[23]}
N 1340 -1080 1470 -1080 {
lab=w[24]}
N 1340 -960 1470 -960 {
lab=w[25]}
N 1340 -840 1470 -840 {
lab=w[26]}
N 1340 -720 1470 -720 {
lab=w[27]}
N 1340 -600 1470 -600 {
lab=w[28]}
N 1340 -480 1470 -480 {
lab=w[29]}
N 1340 -360 1470 -360 {
lab=w[30]}
N 1340 -240 1470 -240 {
lab=w[31]}
C {devices/ipin.sym} 160 -4550 0 0 {name=p1 lab=a[4:0]}
C {devices/ipin.sym} 160 -4680 0 0 {name=p2 lab=VPWR}
C {devices/ipin.sym} 160 -4660 0 0 {name=p3 lab=VGND}
C {devices/lab_wire.sym} 180 -4680 0 1 {name=p4 sig_type=std_logic lab=VPWR}
C {devices/lab_wire.sym} 180 -4660 0 1 {name=p5 sig_type=std_logic lab=VGND}
C {rowdec_not.sym} 280 -4500 0 0 {name=x1 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {devices/bus_connect.sym} 180 -4550 1 0 {name=l1 lab=a[4]}
C {rowdec_not.sym} 280 -4420 0 0 {name=x2 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {devices/bus_connect.sym} 180 -4470 1 0 {name=l2 lab=a[3]}
C {rowdec_not.sym} 280 -4340 0 0 {name=x3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {devices/bus_connect.sym} 180 -4390 1 0 {name=l3 lab=a[2]}
C {rowdec_not.sym} 280 -4260 0 0 {name=x4 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {devices/bus_connect.sym} 180 -4310 1 0 {name=l4 lab=a[1]}
C {rowdec_not.sym} 280 -4180 0 0 {name=x5 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {devices/bus_connect.sym} 180 -4230 1 0 {name=l5 lab=a[0]}
C {rowdec_nand2.sym} 1160 -4080 1 0 {name=x6 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {rowdec_nand2.sym} 1080 -4080 1 0 {name=x7 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {rowdec_nand2.sym} 1000 -4080 1 0 {name=x8 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {rowdec_nand2.sym} 920 -4080 1 0 {name=x9 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {rowdec_nand2.sym} 820 -4080 1 0 {name=x10 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {rowdec_nand2.sym} 740 -4080 1 0 {name=x11 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {rowdec_nand2.sym} 660 -4080 1 0 {name=x12 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {rowdec_nand2.sym} 580 -4080 1 0 {name=x13 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -3960 0 0 {name=x14 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {devices/opin.sym} 1500 -4020 0 0 {name=p6 lab=w[31:0]}
C {rowdec_nor3.sym} 1280 -3840 0 0 {name=x15 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -3720 0 0 {name=x16 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -3600 0 0 {name=x17 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -3480 0 0 {name=x18 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -3360 0 0 {name=x19 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -3240 0 0 {name=x20 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -3120 0 0 {name=x21 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -3000 0 0 {name=x22 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -2880 0 0 {name=x23 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -2760 0 0 {name=x24 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -2640 0 0 {name=x25 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -2520 0 0 {name=x26 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -2400 0 0 {name=x27 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -2280 0 0 {name=x28 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -2160 0 0 {name=x29 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -2040 0 0 {name=x30 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -1920 0 0 {name=x31 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -1800 0 0 {name=x32 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -1680 0 0 {name=x33 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -1560 0 0 {name=x34 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -1440 0 0 {name=x35 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -1320 0 0 {name=x36 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -1200 0 0 {name=x37 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -1080 0 0 {name=x38 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -960 0 0 {name=x39 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -840 0 0 {name=x40 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -720 0 0 {name=x41 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -600 0 0 {name=x42 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -480 0 0 {name=x43 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -360 0 0 {name=x44 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {rowdec_nor3.sym} 1280 -240 0 0 {name=x45 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR}
C {devices/bus_connect.sym} 1480 -3970 3 1 {name=l6 lab=w[0]}
C {devices/bus_connect.sym} 1480 -3850 3 1 {name=l7 lab=w[1]}
C {devices/bus_connect.sym} 1480 -3730 3 1 {name=l8 lab=w[2]}
C {devices/bus_connect.sym} 1480 -3610 3 1 {name=l9 lab=w[3]}
C {devices/bus_connect.sym} 1480 -3490 3 1 {name=l10 lab=w[4]}
C {devices/bus_connect.sym} 1480 -3370 3 1 {name=l11 lab=w[5]}
C {devices/bus_connect.sym} 1480 -3250 3 1 {name=l12 lab=w[6]}
C {devices/bus_connect.sym} 1480 -3130 3 1 {name=l13 lab=w[7]}
C {devices/bus_connect.sym} 1480 -3010 3 1 {name=l14 lab=w[8]}
C {devices/bus_connect.sym} 1480 -2890 3 1 {name=l15 lab=w[9]}
C {devices/bus_connect.sym} 1480 -2770 3 1 {name=l16 lab=w[10]}
C {devices/bus_connect.sym} 1480 -2650 3 1 {name=l17 lab=w[11]}
C {devices/bus_connect.sym} 1480 -2530 3 1 {name=l18 lab=w[12]}
C {devices/bus_connect.sym} 1480 -2410 3 1 {name=l19 lab=w[13]}
C {devices/bus_connect.sym} 1480 -2290 3 1 {name=l20 lab=w[14]}
C {devices/bus_connect.sym} 1480 -2170 3 1 {name=l21 lab=w[15]}
C {devices/bus_connect.sym} 1480 -2050 3 1 {name=l22 lab=w[16]}
C {devices/bus_connect.sym} 1480 -1930 3 1 {name=l23 lab=w[17]}
C {devices/bus_connect.sym} 1480 -1810 3 1 {name=l24 lab=w[18]}
C {devices/bus_connect.sym} 1480 -1690 3 1 {name=l25 lab=w[19]}
C {devices/bus_connect.sym} 1480 -1570 3 1 {name=l26 lab=w[20]}
C {devices/bus_connect.sym} 1480 -1450 3 1 {name=l27 lab=w[21]}
C {devices/bus_connect.sym} 1480 -1330 3 1 {name=l28 lab=w[22]}
C {devices/bus_connect.sym} 1480 -1210 3 1 {name=l29 lab=w[23]}
C {devices/bus_connect.sym} 1480 -1090 3 1 {name=l30 lab=w[24]}
C {devices/bus_connect.sym} 1480 -970 3 1 {name=l31 lab=w[25]}
C {devices/bus_connect.sym} 1480 -850 3 1 {name=l32 lab=w[26]}
C {devices/bus_connect.sym} 1480 -730 3 1 {name=l33 lab=w[27]}
C {devices/bus_connect.sym} 1480 -610 3 1 {name=l34 lab=w[28]}
C {devices/bus_connect.sym} 1480 -490 3 1 {name=l35 lab=w[29]}
C {devices/bus_connect.sym} 1480 -370 3 1 {name=l36 lab=w[30]}
C {devices/bus_connect.sym} 1480 -250 3 1 {name=l37 lab=w[31]}
