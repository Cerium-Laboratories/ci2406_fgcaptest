v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/opin.sym} 1180 -330 0 0 {name=p1 lab=row_en_6v0[29:0]}
C {devices/opin.sym} 1180 -300 0 0 {name=p2 lab=row_en_6v0_b[29:0]}
C {devices/opin.sym} 1180 -250 0 0 {name=p3 lab=vb_o}
C {devices/opin.sym} 1180 -230 0 0 {name=p4 lab=vctrl_o}
C {devices/ipin.sym} 260 -390 0 0 {name=p5 lab=vinj}
C {devices/ipin.sym} 260 -360 0 0 {name=p6 lab=VDD}
C {devices/ipin.sym} 260 -340 0 0 {name=p7 lab=VGND}
C {devices/ipin.sym} 260 -280 0 0 {name=p8 lab=vb_i}
C {devices/ipin.sym} 260 -260 0 0 {name=p9 lab=vctrl_i}
C {devices/ipin.sym} 260 -180 0 0 {name=p10 lab=addr_row[4:0]}
C {devices/ipin.sym} 260 -160 0 0 {name=p11 lab=en}
