v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {NOT YET IMPLEMENTED} 240 -270 0 0 0.4 0.4 {}
C {devices/ipin.sym} 160 -180 0 0 {name=p1 lab=vctrl}
C {devices/ipin.sym} 160 -260 0 0 {name=p2 lab=vtun}
C {devices/ipin.sym} 160 -390 0 0 {name=p3 lab=vinj}
C {devices/ipin.sym} 160 -340 0 0 {name=p4 lab=vinj_en_b}
C {devices/ipin.sym} 160 -130 0 0 {name=p5 lab=vsrc}
C {devices/ipin.sym} 160 -90 0 0 {name=p7 lab=VGND}
C {devices/opin.sym} 580 -250 0 0 {name=p6 lab=vfg}
